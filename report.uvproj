# Keil uVision project report.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: report
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: startup_TM4C123.s code.c keypad.c buttons.c LCD.c logic.c
